#include "zkt_secure.h"

#include <inttypes.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#include "mbedtls/aes.h"
#include "mbedtls/asn1.h"
#include "mbedtls/asn1write.h"
#include "mbedtls/base64.h"
#include "mbedtls/bignum.h"
#include "mbedtls/md.h"
#include "mbedtls/md5.h"
#include "mbedtls/rsa.h"

/*
 * The handshake, the DMC keystream and the AUTH_EXT key are ported from
 * fandbsoft/zkteco4730-java (src/zkteco/ZKTeco4370_ZkCrypto.java), used under
 * its MIT License:
 *
 * Copyright (c) 2026 F&B Soft / Community Contributors
 *
 * Permission is hereby granted, free of charge, to any person obtaining a copy
 * of this software and associated documentation files (the "Software"), to deal
 * in the Software without restriction, including without limitation the rights
 * to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
 * copies of the Software, and to permit persons to whom the Software is
 * furnished to do so, subject to the following conditions:
 *
 * The above copyright notice and this permission notice shall be included in all
 * copies or substantial portions of the Software.
 *
 * THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
 * IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
 * FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
 * AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
 * LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
 * OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
 * SOFTWARE.
 */

#define DMC_CRC_SEED 0xFFEEBBAAu
#define DMC_TYPE_SECRET 2
#define DMC_TYPE_PUBLIC_KEY 3

/* Reflected CRC-32 (polynomial EDB88320), seeded, no final XOR. */
static const uint32_t crc_table[256] = {
    0x00000000u, 0x77073096u, 0xee0e612cu, 0x990951bau, 0x076dc419u, 0x706af48fu,
    0xe963a535u, 0x9e6495a3u, 0x0edb8832u, 0x79dcb8a4u, 0xe0d5e91eu, 0x97d2d988u,
    0x09b64c2bu, 0x7eb17cbdu, 0xe7b82d07u, 0x90bf1d91u, 0x1db71064u, 0x6ab020f2u,
    0xf3b97148u, 0x84be41deu, 0x1adad47du, 0x6ddde4ebu, 0xf4d4b551u, 0x83d385c7u,
    0x136c9856u, 0x646ba8c0u, 0xfd62f97au, 0x8a65c9ecu, 0x14015c4fu, 0x63066cd9u,
    0xfa0f3d63u, 0x8d080df5u, 0x3b6e20c8u, 0x4c69105eu, 0xd56041e4u, 0xa2677172u,
    0x3c03e4d1u, 0x4b04d447u, 0xd20d85fdu, 0xa50ab56bu, 0x35b5a8fau, 0x42b2986cu,
    0xdbbbc9d6u, 0xacbcf940u, 0x32d86ce3u, 0x45df5c75u, 0xdcd60dcfu, 0xabd13d59u,
    0x26d930acu, 0x51de003au, 0xc8d75180u, 0xbfd06116u, 0x21b4f4b5u, 0x56b3c423u,
    0xcfba9599u, 0xb8bda50fu, 0x2802b89eu, 0x5f058808u, 0xc60cd9b2u, 0xb10be924u,
    0x2f6f7c87u, 0x58684c11u, 0xc1611dabu, 0xb6662d3du, 0x76dc4190u, 0x01db7106u,
    0x98d220bcu, 0xefd5102au, 0x71b18589u, 0x06b6b51fu, 0x9fbfe4a5u, 0xe8b8d433u,
    0x7807c9a2u, 0x0f00f934u, 0x9609a88eu, 0xe10e9818u, 0x7f6a0dbbu, 0x086d3d2du,
    0x91646c97u, 0xe6635c01u, 0x6b6b51f4u, 0x1c6c6162u, 0x856530d8u, 0xf262004eu,
    0x6c0695edu, 0x1b01a57bu, 0x8208f4c1u, 0xf50fc457u, 0x65b0d9c6u, 0x12b7e950u,
    0x8bbeb8eau, 0xfcb9887cu, 0x62dd1ddfu, 0x15da2d49u, 0x8cd37cf3u, 0xfbd44c65u,
    0x4db26158u, 0x3ab551ceu, 0xa3bc0074u, 0xd4bb30e2u, 0x4adfa541u, 0x3dd895d7u,
    0xa4d1c46du, 0xd3d6f4fbu, 0x4369e96au, 0x346ed9fcu, 0xad678846u, 0xda60b8d0u,
    0x44042d73u, 0x33031de5u, 0xaa0a4c5fu, 0xdd0d7cc9u, 0x5005713cu, 0x270241aau,
    0xbe0b1010u, 0xc90c2086u, 0x5768b525u, 0x206f85b3u, 0xb966d409u, 0xce61e49fu,
    0x5edef90eu, 0x29d9c998u, 0xb0d09822u, 0xc7d7a8b4u, 0x59b33d17u, 0x2eb40d81u,
    0xb7bd5c3bu, 0xc0ba6cadu, 0xedb88320u, 0x9abfb3b6u, 0x03b6e20cu, 0x74b1d29au,
    0xead54739u, 0x9dd277afu, 0x04db2615u, 0x73dc1683u, 0xe3630b12u, 0x94643b84u,
    0x0d6d6a3eu, 0x7a6a5aa8u, 0xe40ecf0bu, 0x9309ff9du, 0x0a00ae27u, 0x7d079eb1u,
    0xf00f9344u, 0x8708a3d2u, 0x1e01f268u, 0x6906c2feu, 0xf762575du, 0x806567cbu,
    0x196c3671u, 0x6e6b06e7u, 0xfed41b76u, 0x89d32be0u, 0x10da7a5au, 0x67dd4accu,
    0xf9b9df6fu, 0x8ebeeff9u, 0x17b7be43u, 0x60b08ed5u, 0xd6d6a3e8u, 0xa1d1937eu,
    0x38d8c2c4u, 0x4fdff252u, 0xd1bb67f1u, 0xa6bc5767u, 0x3fb506ddu, 0x48b2364bu,
    0xd80d2bdau, 0xaf0a1b4cu, 0x36034af6u, 0x41047a60u, 0xdf60efc3u, 0xa867df55u,
    0x316e8eefu, 0x4669be79u, 0xcb61b38cu, 0xbc66831au, 0x256fd2a0u, 0x5268e236u,
    0xcc0c7795u, 0xbb0b4703u, 0x220216b9u, 0x5505262fu, 0xc5ba3bbeu, 0xb2bd0b28u,
    0x2bb45a92u, 0x5cb36a04u, 0xc2d7ffa7u, 0xb5d0cf31u, 0x2cd99e8bu, 0x5bdeae1du,
    0x9b64c2b0u, 0xec63f226u, 0x756aa39cu, 0x026d930au, 0x9c0906a9u, 0xeb0e363fu,
    0x72076785u, 0x05005713u, 0x95bf4a82u, 0xe2b87a14u, 0x7bb12baeu, 0x0cb61b38u,
    0x92d28e9bu, 0xe5d5be0du, 0x7cdcefb7u, 0x0bdbdf21u, 0x86d3d2d4u, 0xf1d4e242u,
    0x68ddb3f8u, 0x1fda836eu, 0x81be16cdu, 0xf6b9265bu, 0x6fb077e1u, 0x18b74777u,
    0x88085ae6u, 0xff0f6a70u, 0x66063bcau, 0x11010b5cu, 0x8f659effu, 0xf862ae69u,
    0x616bffd3u, 0x166ccf45u, 0xa00ae278u, 0xd70dd2eeu, 0x4e048354u, 0x3903b3c2u,
    0xa7672661u, 0xd06016f7u, 0x4969474du, 0x3e6e77dbu, 0xaed16a4au, 0xd9d65adcu,
    0x40df0b66u, 0x37d83bf0u, 0xa9bcae53u, 0xdebb9ec5u, 0x47b2cf7fu, 0x30b5ffe9u,
    0xbdbdf21cu, 0xcabac28au, 0x53b39330u, 0x24b4a3a6u, 0xbad03605u, 0xcdd70693u,
    0x54de5729u, 0x23d967bfu, 0xb3667a2eu, 0xc4614ab8u, 0x5d681b02u, 0x2a6f2b94u,
    0xb40bbe37u, 0xc30c8ea1u, 0x5a05df1bu, 0x2d02ef8du
};

/* ZKEMCrypto.dll's DMC transform: a symmetric XOR stream (2033 bytes). */
static const uint8_t keystream[] = {
    0xa6, 0x7b, 0xac, 0xbc, 0x5d, 0xfc, 0xef, 0x0c, 0xa5, 0xcd, 0x8d, 0x16, 0x01, 0x36, 0xb9, 0xe4,
    0x1b, 0xf7, 0x34, 0xfc, 0xa6, 0xc3, 0xe8, 0x55, 0x0e, 0xff, 0xf4, 0xe7, 0xa6, 0x78, 0x14, 0xe0,
    0xe8, 0x03, 0xd5, 0x41, 0xfb, 0xdb, 0x51, 0xf9, 0x35, 0x2b, 0x7e, 0x64, 0xcb, 0x05, 0xf2, 0x58,
    0x3c, 0x9d, 0x65, 0x58, 0xac, 0x9d, 0x83, 0x17, 0x23, 0xba, 0x42, 0xa4, 0x25, 0x1a, 0x2d, 0x6f,
    0x7a, 0xc4, 0xbe, 0xaf, 0x79, 0x8d, 0x32, 0x0c, 0x27, 0x7a, 0x11, 0xf6, 0xf2, 0x46, 0xfd, 0xc3,
    0xf8, 0xc4, 0xc6, 0x78, 0x28, 0x58, 0xfe, 0x19, 0x24, 0xef, 0x6c, 0x92, 0x86, 0xee, 0x87, 0x7a,
    0x6b, 0x6c, 0x20, 0x81, 0x62, 0xbe, 0x54, 0x54, 0x2b, 0x68, 0x7c, 0x91, 0x89, 0x82, 0x18, 0xe9,
    0x24, 0xce, 0x9b, 0x6a, 0x0f, 0x9f, 0x5b, 0x0d, 0xec, 0xfe, 0x84, 0x87, 0x1a, 0xad, 0xbe, 0x38,
    0x7e, 0x7a, 0x91, 0x92, 0x77, 0x4b, 0xf1, 0x21, 0xf8, 0x75, 0xb8, 0xb6, 0x42, 0xc0, 0x67, 0xd7,
    0xc3, 0x01, 0x0f, 0x2b, 0x10, 0x61, 0x5d, 0xa6, 0x7e, 0x48, 0xea, 0x08, 0x6a, 0x88, 0x80, 0x9f,
    0x23, 0x91, 0x7d, 0xb8, 0xa1, 0xdf, 0xa0, 0x54, 0xec, 0x59, 0x6d, 0x4c, 0x42, 0x81, 0xf3, 0x0a,
    0x9f, 0xff, 0x8a, 0xf7, 0x5c, 0x97, 0x0d, 0xac, 0x4d, 0xd4, 0x74, 0x71, 0xbc, 0x92, 0xc6, 0xef,
    0xcc, 0x40, 0x97, 0xed, 0xa8, 0xa0, 0x3e, 0x82, 0xa2, 0x93, 0x96, 0xb8, 0x94, 0x3e, 0x60, 0x7b,
    0x31, 0xd7, 0x80, 0x12, 0xe6, 0x73, 0xca, 0xc5, 0xf5, 0xa0, 0x1f, 0x0d, 0xf4, 0x4f, 0x3c, 0x32,
    0xab, 0x97, 0x0a, 0x60, 0x37, 0x8d, 0xa8, 0x0b, 0xcd, 0xae, 0x35, 0x28, 0xdc, 0x9a, 0x6b, 0x8e,
    0x3a, 0xf8, 0xc1, 0x59, 0x3e, 0x17, 0xe1, 0xcb, 0x0e, 0x78, 0x69, 0x6e, 0xb1, 0x3f, 0xf2, 0xf3,
    0x30, 0x5d, 0x3d, 0x93, 0xb3, 0xaa, 0x43, 0x74, 0x4d, 0xf4, 0xe9, 0xc6, 0xe8, 0x35, 0xe2, 0xfe,
    0x3a, 0x0e, 0xec, 0x23, 0x3f, 0xe5, 0x71, 0x33, 0xcb, 0x0a, 0x73, 0xc3, 0xa4, 0x59, 0x63, 0x91,
    0xc8, 0x74, 0x74, 0xaa, 0x20, 0x12, 0x90, 0xfa, 0x06, 0x5e, 0x2e, 0x55, 0x4c, 0xbb, 0xae, 0xd1,
    0xcd, 0x92, 0xe5, 0x22, 0xa4, 0xd6, 0xbd, 0x62, 0xb0, 0x96, 0x98, 0x73, 0x63, 0xc6, 0xdb, 0x45,
    0xe7, 0xd5, 0xcd, 0xb2, 0xf6, 0x89, 0x1f, 0xd6, 0x39, 0x24, 0x4d, 0x83, 0xba, 0x11, 0xd2, 0xa1,
    0x7e, 0x27, 0x47, 0x2f, 0xdb, 0x7e, 0xd5, 0x5d, 0x7d, 0xab, 0x87, 0x05, 0x64, 0xa2, 0xc8, 0xf5,
    0xdb, 0x00, 0xdc, 0x80, 0x35, 0x1d, 0x0c, 0xf9, 0xce, 0xf0, 0x84, 0xe4, 0x86, 0x81, 0xc4, 0x8d,
    0x97, 0x3d, 0xb9, 0x44, 0x94, 0xcd, 0xb9, 0x2c, 0xde, 0x8f, 0xc3, 0x07, 0xe0, 0xe1, 0x91, 0xb9,
    0x5c, 0xda, 0x91, 0x7d, 0xc1, 0xbf, 0x89, 0x1e, 0x01, 0xe1, 0x11, 0xe5, 0xed, 0x81, 0xc0, 0xf3,
    0x60, 0xab, 0x8b, 0x4e, 0xa0, 0xf6, 0x2b, 0xce, 0xc3, 0x95, 0x7a, 0xa2, 0xa0, 0x08, 0xcb, 0x33,
    0x2f, 0x4c, 0x12, 0xd9, 0x07, 0xd2, 0xec, 0xb0, 0x2b, 0xca, 0x0d, 0x1c, 0x70, 0x99, 0xae, 0x48,
    0xdf, 0x9b, 0xcd, 0x59, 0x57, 0xbd, 0xa1, 0x1e, 0xdc, 0x7a, 0x93, 0x19, 0xd9, 0xd9, 0xbf, 0x81,
    0x22, 0xd1, 0xe8, 0x3d, 0x65, 0x9a, 0x8b, 0x18, 0xcf, 0xe8, 0x6b, 0x7a, 0x0d, 0x83, 0x44, 0x21,
    0xd3, 0x10, 0x04, 0x83, 0x8c, 0xaa, 0xd2, 0x86, 0x42, 0xb5, 0xc3, 0xe1, 0x1c, 0xfd, 0x27, 0x80,
    0xe5, 0x5b, 0x6f, 0x14, 0x9a, 0x48, 0x51, 0x76, 0x9c, 0x64, 0xd1, 0x24, 0x61, 0xc7, 0x5f, 0x18,
    0xf1, 0x29, 0xac, 0x82, 0x64, 0xdf, 0x47, 0x8c, 0xd8, 0xf8, 0xb5, 0xaf, 0x8c, 0xdc, 0xa0, 0x6f,
    0x02, 0x9e, 0xeb, 0xa4, 0xcd, 0x18, 0x96, 0xc9, 0xc6, 0xb2, 0x52, 0x93, 0x24, 0xa0, 0xdd, 0xff,
    0x3b, 0xde, 0x5c, 0xb5, 0x79, 0xf2, 0x90, 0x42, 0x3f, 0x41, 0x52, 0x96, 0x36, 0xe9, 0x1d, 0x68,
    0x80, 0xa6, 0xf4, 0xae, 0xfc, 0x2a, 0x43, 0xd4, 0x5b, 0x67, 0x27, 0x69, 0x49, 0xca, 0x28, 0xe5,
    0x6d, 0x3f, 0x35, 0xef, 0x84, 0xbb, 0xfa, 0x7c, 0x81, 0xa9, 0x6b, 0x27, 0x55, 0x5f, 0x50, 0x84,
    0xca, 0x60, 0x67, 0x49, 0xd8, 0x2f, 0x6e, 0x13, 0xc1, 0x39, 0x48, 0xa0, 0x1d, 0x69, 0xe1, 0x6f,
    0x79, 0xc3, 0x33, 0xce, 0x84, 0xd1, 0x06, 0x09, 0xd3, 0x45, 0xbc, 0xb9, 0x41, 0xdd, 0x66, 0x1c,
    0xd2, 0x5c, 0x1e, 0x87, 0x4a, 0x0a, 0x5c, 0xd3, 0x82, 0x8f, 0xad, 0x5a, 0x1f, 0x41, 0x46, 0xe5,
    0xf5, 0x69, 0xe1, 0xc5, 0x87, 0xe4, 0x86, 0x4a, 0xf5, 0xc7, 0x18, 0xdb, 0xe0, 0xb1, 0xfc, 0x23,
    0x19, 0xe4, 0x62, 0xc4, 0xf9, 0xf4, 0x2b, 0x9a, 0x5b, 0xc1, 0xd7, 0x60, 0x41, 0xa9, 0xdb, 0x7d,
    0xc7, 0x0e, 0xbb, 0xfa, 0x95, 0x1f, 0x5f, 0xa6, 0x5d, 0xb7, 0x13, 0x28, 0xa2, 0xa9, 0x8f, 0x18,
    0x80, 0xcf, 0x54, 0xf9, 0xf7, 0x89, 0x6f, 0x86, 0x4a, 0x46, 0xc8, 0xa1, 0x8a, 0x30, 0x25, 0x43,
    0xe3, 0x38, 0x46, 0xbe, 0x30, 0x6f, 0xc6, 0x5f, 0xf9, 0x79, 0xec, 0xf3, 0xff, 0x1e, 0xb0, 0x32,
    0xe6, 0xfb, 0x03, 0x65, 0xb6, 0x93, 0x46, 0x66, 0x77, 0x10, 0xc1, 0xc6, 0xa1, 0xd5, 0x70, 0xc2,
    0x43, 0x76, 0x73, 0xec, 0xba, 0x00, 0x09, 0xf3, 0x31, 0xa0, 0xb5, 0xd5, 0x03, 0x6e, 0xc1, 0x76,
    0x3b, 0xd7, 0x53, 0x87, 0x72, 0x0b, 0x22, 0x0d, 0x4b, 0x89, 0xf7, 0xb7, 0x10, 0x11, 0xc5, 0xd2,
    0xe8, 0x50, 0x53, 0x07, 0xa6, 0xf6, 0x52, 0xc3, 0xa1, 0x98, 0xd6, 0x4f, 0xc4, 0x00, 0x94, 0xeb,
    0xeb, 0x8f, 0x7a, 0x2e, 0x35, 0x8b, 0x1b, 0x7e, 0x5f, 0xaa, 0x04, 0xab, 0x96, 0x3b, 0xf1, 0xc1,
    0x03, 0xd8, 0x84, 0xa1, 0xcb, 0x7a, 0xc1, 0xb7, 0x1d, 0xfb, 0x2b, 0x62, 0xf1, 0xc9, 0xcc, 0x31,
    0x81, 0x40, 0xdb, 0xc5, 0xe4, 0x07, 0x41, 0x35, 0x02, 0x81, 0xe1, 0xa3, 0x03, 0x0d, 0xf9, 0x52,
    0xe3, 0x38, 0xa5, 0x3a, 0x28, 0xc0, 0xa5, 0x24, 0x32, 0xb9, 0x16, 0x69, 0x38, 0xe1, 0x4c, 0x9c,
    0x8f, 0x7e, 0x17, 0x0b, 0x03, 0x7a, 0xad, 0xe0, 0xab, 0x05, 0xaf, 0xe4, 0x14, 0x17, 0x86, 0x12,
    0xaa, 0x40, 0x38, 0x88, 0x94, 0x63, 0x22, 0xc9, 0xad, 0x19, 0xa7, 0x81, 0x3a, 0x40, 0x02, 0x29,
    0xbb, 0x5a, 0x50, 0xbc, 0xe0, 0x7d, 0xbb, 0xec, 0x2d, 0x38, 0x42, 0x40, 0x70, 0xa1, 0x4e, 0xc9,
    0x76, 0xee, 0x58, 0x21, 0x47, 0x38, 0x76, 0x19, 0xa0, 0x71, 0x4d, 0xf0, 0x82, 0x19, 0xe6, 0x85,
    0xa9, 0x0d, 0x33, 0xdd, 0xb3, 0xc9, 0x25, 0x7b, 0x5a, 0x0f, 0x5f, 0x94, 0x04, 0x23, 0x98, 0x18,
    0xee, 0x8a, 0x7e, 0x53, 0x55, 0x0a, 0xe0, 0x12, 0xad, 0x06, 0x7a, 0x4a, 0x15, 0x70, 0x86, 0xe3,
    0xba, 0x88, 0xb4, 0xc9, 0x8b, 0x9a, 0xc1, 0xee, 0x14, 0x83, 0x71, 0x63, 0x64, 0x37, 0xca, 0x58,
    0x3e, 0x07, 0xc9, 0x1c, 0x8a, 0x04, 0xd3, 0xe1, 0xda, 0xfd, 0xbc, 0x9a, 0xa1, 0xa0, 0x82, 0x6f,
    0x48, 0x30, 0x8f, 0x1f, 0x3b, 0x92, 0x12, 0xa7, 0xd2, 0x15, 0xa0, 0x11, 0x44, 0xa7, 0xc3, 0x00,
    0x30, 0x4e, 0xae, 0xe5, 0x98, 0xc7, 0x9d, 0x66, 0xaa, 0x0a, 0x19, 0x27, 0x1a, 0x12, 0x53, 0x3a,
    0x5e, 0xb0, 0x96, 0x67, 0x52, 0x84, 0xec, 0x37, 0x96, 0x2a, 0x49, 0xa4, 0x51, 0x95, 0x4a, 0x27,
    0x41, 0x7c, 0x67, 0x39, 0x9e, 0x1b, 0xcc, 0x32, 0x29, 0x0c, 0x6d, 0xf1, 0x8f, 0x47, 0x58, 0x08,
    0xfa, 0xe4, 0x22, 0x40, 0x82, 0xa0, 0x37, 0x31, 0xcc, 0xfa, 0x35, 0xcc, 0x66, 0x9d, 0x7d, 0x92,
    0x04, 0x37, 0xd5, 0xb0, 0x2c, 0xb7, 0x62, 0x79, 0x2d, 0x7a, 0x12, 0xa6, 0xec, 0xe1, 0x2b, 0xd8,
    0xfd, 0x98, 0x72, 0x82, 0x26, 0x75, 0xd4, 0x0c, 0xca, 0x03, 0x86, 0xfe, 0xf4, 0xa3, 0x65, 0x1a,
    0xe9, 0xc2, 0x97, 0x7d, 0x82, 0xc5, 0xf2, 0x33, 0x1d, 0xf8, 0x57, 0x5d, 0x78, 0xdd, 0x39, 0x28,
    0x15, 0x9b, 0xb5, 0x95, 0x0b, 0x8e, 0xcf, 0x6b, 0x3f, 0x9e, 0x89, 0x4b, 0xa6, 0x46, 0x88, 0x25,
    0x27, 0x78, 0x45, 0x0e, 0xfb, 0x45, 0xf0, 0xf9, 0x94, 0xe0, 0x57, 0x8d, 0xde, 0x8a, 0x54, 0x4b,
    0xfb, 0x6c, 0xac, 0x1c, 0xa5, 0x90, 0xcc, 0x1b, 0x5b, 0xf0, 0x4b, 0x43, 0x80, 0x1e, 0x5d, 0xf6,
    0x07, 0xf0, 0x2b, 0x4a, 0x1b, 0x27, 0x60, 0xec, 0x19, 0xe9, 0x88, 0x36, 0x65, 0x42, 0xc9, 0xfa,
    0x5a, 0x4b, 0xd6, 0xb8, 0x44, 0xf1, 0xaf, 0x32, 0x13, 0x80, 0x74, 0xd4, 0x2a, 0x4c, 0xb5, 0x3b,
    0x12, 0xd0, 0xfa, 0xef, 0x02, 0xc0, 0x8d, 0x35, 0xf1, 0x41, 0xbb, 0x22, 0x89, 0xaa, 0x25, 0x28,
    0x8f, 0x0b, 0x88, 0x57, 0xa7, 0x1f, 0x8e, 0x02, 0xeb, 0x72, 0x18, 0x1e, 0x87, 0xce, 0x3a, 0x4a,
    0xb9, 0x14, 0x54, 0x52, 0x9b, 0x8b, 0xc2, 0xe7, 0xd7, 0x84, 0x9c, 0x2e, 0x5d, 0x00, 0xd3, 0x15,
    0x25, 0x77, 0x04, 0x54, 0xae, 0x89, 0x76, 0xd8, 0xe4, 0x64, 0x93, 0x85, 0xf1, 0x68, 0x64, 0xa4,
    0x91, 0xcf, 0xa1, 0x47, 0xd2, 0x8f, 0xf2, 0x45, 0x2c, 0x99, 0xe7, 0x17, 0x93, 0x38, 0x02, 0x70,
    0xd0, 0x4e, 0x5f, 0xb6, 0x0a, 0xa2, 0x8c, 0x01, 0x9e, 0xd3, 0x5d, 0xf7, 0xe7, 0x2a, 0x59, 0x07,
    0x3b, 0x4e, 0x80, 0x13, 0x1c, 0xc5, 0xc4, 0x2e, 0xfa, 0xf9, 0x1d, 0x50, 0xe1, 0x2a, 0xd5, 0xeb,
    0x26, 0xfa, 0xce, 0x74, 0x47, 0x14, 0xfe, 0xa1, 0x80, 0xd5, 0x94, 0x5d, 0x26, 0xb6, 0xb4, 0x8e,
    0x64, 0x10, 0x11, 0xc9, 0x1f, 0x41, 0x77, 0x38, 0xa2, 0x71, 0x70, 0x18, 0x93, 0xbb, 0xba, 0x26,
    0x83, 0xb3, 0x51, 0xb7, 0xbc, 0x46, 0x88, 0x42, 0xb4, 0x7a, 0x30, 0x4f, 0xf0, 0xe3, 0x0f, 0xc7,
    0x56, 0x50, 0x4b, 0x71, 0x26, 0xef, 0x1d, 0x93, 0xe0, 0x83, 0xdc, 0x1b, 0x71, 0x98, 0xb8, 0xaf,
    0xac, 0x0c, 0x25, 0x39, 0xee, 0xa0, 0x4b, 0xe8, 0x92, 0x2e, 0xd9, 0xc7, 0x28, 0x16, 0xa7, 0x03,
    0x42, 0x7f, 0x7d, 0x2c, 0x2e, 0xbf, 0x06, 0x66, 0xf5, 0x08, 0x65, 0xd6, 0xa0, 0x42, 0x5c, 0x65,
    0x38, 0xd1, 0x70, 0x2b, 0xdd, 0x1a, 0xa1, 0x0c, 0x4f, 0x3e, 0xeb, 0x26, 0x54, 0x69, 0x19, 0xce,
    0x4a, 0x2c, 0xc0, 0xaf, 0x70, 0xca, 0xe6, 0xe3, 0xaa, 0x21, 0xda, 0x3a, 0xb9, 0xf1, 0x06, 0xa8,
    0xac, 0xbc, 0x89, 0xfd, 0x75, 0xdf, 0xa2, 0x06, 0x71, 0xf1, 0x1b, 0x24, 0xbc, 0xf4, 0xb2, 0x2c,
    0x98, 0xfa, 0xae, 0x1a, 0x61, 0x22, 0xdc, 0xfc, 0x4e, 0xdf, 0x11, 0x4c, 0xb1, 0x97, 0xf8, 0x3d,
    0x9b, 0xf3, 0x1a, 0x49, 0x80, 0xde, 0xf1, 0x1a, 0xe6, 0xad, 0x76, 0xba, 0x07, 0x0b, 0x7c, 0x0d,
    0x25, 0x9c, 0xba, 0x6f, 0x41, 0x27, 0x0c, 0xd5, 0x19, 0x07, 0xb1, 0xaf, 0xc5, 0x1a, 0x3f, 0x23,
    0x5b, 0x77, 0x16, 0x6a, 0x1c, 0xb4, 0x9c, 0x01, 0xa6, 0x1e, 0x0c, 0xd1, 0xa3, 0x87, 0x3c, 0xa9,
    0x61, 0x0d, 0xe8, 0x71, 0xb1, 0xb2, 0x0c, 0xfb, 0x62, 0xf9, 0x6f, 0xf6, 0x48, 0x12, 0x7f, 0xd4,
    0xea, 0x5d, 0xe3, 0x5c, 0xce, 0xd6, 0x0e, 0x6c, 0xce, 0x0b, 0xd9, 0x53, 0x90, 0xa1, 0x90, 0xeb,
    0x28, 0xf4, 0x3d, 0xeb, 0x17, 0x75, 0x02, 0x8a, 0x4e, 0x50, 0x1b, 0x84, 0xc2, 0xc5, 0x46, 0xf9,
    0x62, 0xb4, 0x40, 0xdd, 0x48, 0x61, 0x5e, 0x13, 0x88, 0x48, 0xac, 0x3b, 0x19, 0x60, 0x9f, 0x72,
    0xb9, 0x23, 0xec, 0xc3, 0x12, 0x13, 0x39, 0x72, 0x75, 0xc2, 0xa9, 0x56, 0x7e, 0x58, 0x58, 0xdf,
    0x01, 0xf2, 0x9a, 0x84, 0x0e, 0xb7, 0xc1, 0x4c, 0xa0, 0xae, 0x08, 0x70, 0x05, 0x5a, 0x58, 0xb0,
    0xc3, 0x20, 0xf5, 0x13, 0x06, 0x1e, 0x7b, 0xa7, 0xb6, 0xf3, 0xdf, 0xca, 0x7a, 0xcc, 0x81, 0x1d,
    0x05, 0x49, 0x98, 0x61, 0xed, 0xff, 0x86, 0x24, 0x25, 0x6b, 0x3f, 0x59, 0x55, 0x4d, 0x56, 0x14,
    0x2e, 0xf1, 0xf9, 0xbf, 0x79, 0x7a, 0xe4, 0x5b, 0x48, 0xb0, 0xda, 0x6c, 0xa3, 0x0f, 0x5c, 0x9a,
    0xcb, 0x45, 0x38, 0x9f, 0x77, 0x23, 0x28, 0x24, 0x86, 0x8a, 0x58, 0x39, 0x3c, 0x56, 0xc0, 0xbc,
    0xe0, 0x09, 0xa7, 0xd3, 0xaf, 0x63, 0xb2, 0x25, 0xba, 0x70, 0xaa, 0x71, 0xc9, 0x21, 0x59, 0x44,
    0x34, 0x26, 0x36, 0xd1, 0x75, 0xaf, 0x6f, 0x10, 0xa3, 0x49, 0xfc, 0x10, 0xe2, 0x86, 0xde, 0xb0,
    0xf4, 0x96, 0x7a, 0xac, 0xd6, 0x6f, 0x32, 0xca, 0xfc, 0x83, 0x51, 0x8c, 0x8c, 0xf9, 0xd4, 0x4c,
    0xbe, 0x33, 0xfb, 0xa0, 0x12, 0xcd, 0xb3, 0xe3, 0x1d, 0x4e, 0x79, 0x65, 0xfb, 0x37, 0x8f, 0xfa,
    0xc8, 0x53, 0x42, 0x8e, 0xda, 0x33, 0xab, 0xc8, 0xdc, 0x17, 0xb2, 0xb6, 0xd5, 0x23, 0xe9, 0x1e,
    0x05, 0x5d, 0xcf, 0xea, 0xc4, 0x44, 0x6f, 0xc3, 0x4b, 0xb9, 0x3d, 0x16, 0x2e, 0x6a, 0x5c, 0xf6,
    0x6a, 0x86, 0x13, 0xbf, 0x08, 0x78, 0x5c, 0x2c, 0x8f, 0x40, 0x96, 0x23, 0x8b, 0xab, 0x50, 0xc8,
    0x26, 0xd9, 0x93, 0x0c, 0x60, 0x2e, 0xe9, 0x9f, 0xf8, 0xf5, 0x1d, 0xfe, 0xc8, 0xaa, 0xb3, 0x05,
    0x8f, 0x6d, 0x1c, 0x01, 0x75, 0x7f, 0xfd, 0x0f, 0xec, 0xc1, 0x7d, 0x34, 0x19, 0xea, 0xf6, 0xf9,
    0xaa, 0xb2, 0x18, 0x3b, 0x55, 0x0d, 0x63, 0x7f, 0xc9, 0xec, 0xd7, 0x45, 0x33, 0x02, 0x89, 0xd4,
    0x79, 0x6e, 0x33, 0x9e, 0x47, 0x60, 0xf4, 0x33, 0xae, 0xad, 0xc7, 0xa7, 0x48, 0xd0, 0x21, 0x00,
    0x88, 0xbb, 0x6c, 0x7a, 0x35, 0x62, 0xf6, 0xc7, 0x37, 0xc1, 0xf9, 0xa1, 0x6d, 0x8d, 0x04, 0x9d,
    0xe4, 0x44, 0x3a, 0x86, 0xeb, 0x71, 0x9f, 0x68, 0x3a, 0xe4, 0x36, 0xd9, 0xcf, 0xf8, 0x0d, 0xa8,
    0xad, 0x82, 0x22, 0x81, 0x58, 0x2a, 0xc0, 0xf1, 0x98, 0x3a, 0xa2, 0xd8, 0x14, 0x05, 0x21, 0xea,
    0xc9, 0x7f, 0x8d, 0x9e, 0x5a, 0x9c, 0x2f, 0x9c, 0x21, 0x4e, 0x51, 0x6a, 0x9e, 0x71, 0x44, 0xbd,
    0x27, 0xdc, 0x00, 0x16, 0xbf, 0xa5, 0xfc, 0x9b, 0xe3, 0x64, 0x4b, 0x8f, 0x10, 0xdb, 0x49, 0x8f,
    0xd7, 0x59, 0x15, 0xfe, 0x22, 0xf1, 0xbc, 0xa3, 0x77, 0x38, 0x57, 0x1e, 0x4a, 0x6e, 0x7c, 0x72,
    0xf8, 0x48, 0x64, 0x9d, 0xd6, 0x09, 0x83, 0xe2, 0xef, 0x71, 0xc5, 0x90, 0x8c, 0xe9, 0x6e, 0xf4,
    0xde, 0x8f, 0x47, 0x42, 0xf4, 0x5c, 0x95, 0xf2, 0xb7, 0xd2, 0xad, 0x7f, 0xe6, 0xdb, 0x3e, 0x08,
    0x5c, 0x49, 0xc5, 0x67, 0x20, 0x0d, 0xbf, 0x45, 0x57, 0x6e, 0x94, 0x6f, 0x13, 0x30, 0x3c, 0x99,
    0xed, 0x71, 0x4d, 0x22, 0x94, 0x32, 0x8b, 0x34, 0xcc, 0xd2, 0xa1, 0x10, 0xcc, 0xeb, 0x6d, 0x97,
    0xf9, 0x9d, 0x27, 0x46, 0xbc, 0xd1, 0xcd, 0xa0, 0xc9, 0x80, 0x4b, 0x3f, 0xe5, 0x50, 0xe4, 0x34,
    0x72, 0x34, 0x83, 0x15, 0x9c, 0x3e, 0x33, 0xaa, 0xc0, 0xb3, 0xe1, 0x49, 0x18, 0x01, 0x9b, 0x30,
    0xb5, 0x8f, 0x16, 0xe3, 0x37, 0xa4, 0x43, 0xb2, 0x15, 0x7a, 0x15, 0xbe, 0x05, 0x36, 0x38, 0x13,
    0x10
};

static void put_le16(uint8_t *out, uint32_t value)
{
    out[0] = (uint8_t)value;
    out[1] = (uint8_t)(value >> 8);
}

static void put_le32(uint8_t *out, uint32_t value)
{
    out[0] = (uint8_t)value;
    out[1] = (uint8_t)(value >> 8);
    out[2] = (uint8_t)(value >> 16);
    out[3] = (uint8_t)(value >> 24);
}

static uint32_t get_le32(const uint8_t *in)
{
    return (uint32_t)in[0] | (uint32_t)in[1] << 8 | (uint32_t)in[2] << 16 | (uint32_t)in[3] << 24;
}

const char *zkt_secure_status_name(zkt_secure_status_t status)
{
    switch (status) {
    case ZKT_SECURE_OK: return "OK";
    case ZKT_SECURE_ERR_ARGUMENT: return "ARGUMENT";
    case ZKT_SECURE_ERR_MEMORY: return "MEMORY";
    case ZKT_SECURE_ERR_KEYGEN: return "KEYGEN";
    case ZKT_SECURE_ERR_ENCODING: return "ENCODING";
    case ZKT_SECURE_ERR_PEER_KEY: return "PEER_KEY";
    case ZKT_SECURE_ERR_RSA: return "RSA";
    case ZKT_SECURE_ERR_AES: return "AES";
    case ZKT_SECURE_ERR_DIGEST: return "DIGEST";
    case ZKT_SECURE_ERR_FRAME: return "FRAME";
    }
    return "UNKNOWN";
}

uint32_t zkt_secure_crc32(const uint8_t *data, size_t length)
{
    uint32_t crc = DMC_CRC_SEED;
    for (size_t i = 0; i < length; ++i) {
        crc = (crc >> 8) ^ crc_table[(data[i] ^ crc) & 0xFFu];
    }
    return crc;
}

size_t zkt_secure_keystream_length(void)
{
    return sizeof(keystream);
}

bool zkt_secure_keystream_apply(uint8_t *data, size_t length)
{
    if (!data || length > sizeof(keystream)) return false;
    for (size_t i = 0; i < length; ++i) data[i] ^= keystream[i];
    return true;
}

bool zkt_secure_dmc_build(uint8_t type, const uint8_t *body, size_t body_length,
    uint8_t *output, size_t capacity, size_t *written)
{
    if (!output || !written || (body_length && !body) || body_length > 0xFFFFu ||
        capacity < body_length + 9) return false;
    output[0] = 0xAA;
    output[1] = 0xBB;
    output[2] = type;
    put_le16(output + 3, (uint32_t)body_length);
    if (body_length) memmove(output + 5, body, body_length);
    put_le32(output + 5 + body_length, zkt_secure_crc32(output + 5, body_length));
    *written = body_length + 9;
    return true;
}

bool zkt_secure_dmc_parse(const uint8_t *plain, size_t length, uint8_t *type,
    const uint8_t **body, size_t *body_length)
{
    if (!plain || !type || !body || !body_length || length < 9 ||
        plain[0] != 0xAA || plain[1] != 0xBB) return false;
    size_t declared = (size_t)plain[3] | (size_t)plain[4] << 8;
    if (declared + 9 > length ||
        get_le32(plain + 5 + declared) != zkt_secure_crc32(plain + 5, declared)) return false;
    *type = plain[2];
    *body = plain + 5;
    *body_length = declared;
    return true;
}

void zkt_secure_derive_aes_key(uint32_t client_secret, uint32_t server_secret,
    uint8_t key[ZKT_SECURE_KEY_BYTES])
{
    char text[40];
    int length = snprintf(text, sizeof(text), "%" PRIu32 ".%" PRIu32 ".%" PRIu32,
        client_secret ^ server_secret, (server_secret << 8) ^ client_secret,
        (client_secret << 8) ^ server_secret);
    memset(key, 0, ZKT_SECURE_KEY_BYTES);
    if (length > 0) {
        memcpy(key, text, (size_t)length < ZKT_SECURE_KEY_BYTES ? (size_t)length : ZKT_SECURE_KEY_BYTES);
    }
}

void zkt_secure_commkey_native(uint32_t comm_key, uint16_t session_id, uint8_t tick,
    uint8_t output[4])
{
    uint32_t key = 0;
    for (unsigned bit = 0; bit < 32; ++bit) key = key << 1 | ((comm_key >> bit) & 1u);
    key += session_id;
    output[0] = (uint8_t)(((key >> 16) & 0xFFu) ^ 0x53u ^ tick);
    output[1] = (uint8_t)(((key >> 24) & 0xFFu) ^ 0x4Fu ^ tick);
    output[2] = tick;
    output[3] = (uint8_t)(((key >> 8) & 0xFFu) ^ 0x4Bu ^ tick);
}

static void hex_lower(const uint8_t *in, size_t length, char *out)
{
    static const char digits[] = "0123456789abcdef";
    for (size_t i = 0; i < length; ++i) {
        out[2 * i] = digits[in[i] >> 4];
        out[2 * i + 1] = digits[in[i] & 0x0Fu];
    }
}

zkt_secure_status_t zkt_secure_auth_ext_payload(uint32_t comm_key,
    uint8_t output[ZKT_SECURE_AUTH_EXT_BYTES])
{
    static const char seed_key[] = "ZKTeco-secret-key";
    static const char seed_text[] = "StandalongComm";
    if (!output) return ZKT_SECURE_ERR_ARGUMENT;
    const mbedtls_md_info_t *sha256 = mbedtls_md_info_from_type(MBEDTLS_MD_SHA256);
    uint8_t seed[32];
    uint8_t digest[16];
    char seed_hex[64];
    char digest_hex[32];
    char text[11];
    int text_length = snprintf(text, sizeof(text), "%" PRIu32, comm_key);
    if (!sha256 || text_length <= 0 ||
        mbedtls_md_hmac(sha256, (const unsigned char *)seed_key, sizeof(seed_key) - 1,
            (const unsigned char *)seed_text, sizeof(seed_text) - 1, seed) != 0 ||
        mbedtls_md5((const unsigned char *)text, (size_t)text_length, digest) != 0) {
        return ZKT_SECURE_ERR_DIGEST;
    }
    hex_lower(seed, sizeof(seed), seed_hex);
    hex_lower(digest, sizeof(digest), digest_hex);
    if (mbedtls_md_hmac(sha256, (const unsigned char *)seed_hex, sizeof(seed_hex),
            (const unsigned char *)digest_hex, sizeof(digest_hex), output) != 0) {
        return ZKT_SECURE_ERR_DIGEST;
    }
    output[32] = 0xB3;
    output[33] = 0xF6;
    output[34] = 0x00;
    output[35] = 0x01;
    return ZKT_SECURE_OK;
}

/* PKCS#1 RSAPublicKey DER, SEQUENCE { n, e }, written backwards. */
static int write_public_der(const mbedtls_mpi *n, const mbedtls_mpi *e,
    unsigned char *buffer, size_t capacity, unsigned char **start)
{
    unsigned char *p = buffer + capacity;
    int length = 0;
    int step = mbedtls_asn1_write_mpi(&p, buffer, e);
    if (step < 0) return step;
    length += step;
    if ((step = mbedtls_asn1_write_mpi(&p, buffer, n)) < 0) return step;
    length += step;
    if ((step = mbedtls_asn1_write_len(&p, buffer, (size_t)length)) < 0) return step;
    length += step;
    if ((step = mbedtls_asn1_write_tag(&p, buffer,
             MBEDTLS_ASN1_CONSTRUCTED | MBEDTLS_ASN1_SEQUENCE)) < 0) return step;
    length += step;
    *start = p;
    return length;
}

/* The vendor's PEM: armour lines and 64-column base64, each line ending \n. */
static bool write_public_pem(const unsigned char *der, size_t der_length,
    char *pem, size_t capacity, size_t *written)
{
    static const char header[] = "-----BEGIN RSA PUBLIC KEY-----\n";
    static const char footer[] = "-----END RSA PUBLIC KEY-----\n";
    unsigned char text[ZKT_SECURE_PEM_MAX];
    size_t text_length = 0;
    if (mbedtls_base64_encode(text, sizeof(text), &text_length, der, der_length) != 0) return false;
    size_t needed = sizeof(header) - 1 + text_length + (text_length + 63) / 64 + sizeof(footer) - 1;
    if (needed >= capacity) return false;
    size_t at = sizeof(header) - 1;
    memcpy(pem, header, at);
    for (size_t i = 0; i < text_length; i += 64) {
        size_t chunk = text_length - i < 64 ? text_length - i : 64;
        memcpy(pem + at, text + i, chunk);
        at += chunk;
        pem[at++] = '\n';
    }
    memcpy(pem + at, footer, sizeof(footer) - 1);
    at += sizeof(footer) - 1;
    pem[at] = '\0';
    *written = at;
    return true;
}

zkt_secure_status_t zkt_secure_identity_generate(zkt_secure_identity_t *identity,
    unsigned bits, zkt_secure_rng_t rng, void *rng_context)
{
    if (!identity || !rng || bits < 1024 || bits > 4096) return ZKT_SECURE_ERR_ARGUMENT;
    memset(identity, 0, sizeof(*identity));
    mbedtls_rsa_context *rsa = calloc(1, sizeof(*rsa));
    unsigned char *der = malloc(ZKT_SECURE_PEM_MAX);
    if (!rsa || !der) {
        free(rsa);
        free(der);
        return ZKT_SECURE_ERR_MEMORY;
    }
    mbedtls_rsa_init(rsa);
    mbedtls_mpi n;
    mbedtls_mpi e;
    mbedtls_mpi_init(&n);
    mbedtls_mpi_init(&e);
    zkt_secure_status_t status = ZKT_SECURE_ERR_KEYGEN;
    if (mbedtls_rsa_gen_key(rsa, rng, rng_context, bits, 65537) == 0 &&
        mbedtls_rsa_export(rsa, &n, NULL, NULL, NULL, &e) == 0) {
        unsigned char *start = NULL;
        int der_length = write_public_der(&n, &e, der, ZKT_SECURE_PEM_MAX, &start);
        status = der_length > 0 && write_public_pem(start, (size_t)der_length, identity->pem,
                     sizeof(identity->pem), &identity->pem_length)
            ? ZKT_SECURE_OK
            : ZKT_SECURE_ERR_ENCODING;
    }
    mbedtls_mpi_free(&n);
    mbedtls_mpi_free(&e);
    free(der);
    if (status != ZKT_SECURE_OK) {
        mbedtls_rsa_free(rsa);
        free(rsa);
        memset(identity, 0, sizeof(*identity));
        return status;
    }
    identity->rsa = rsa;
    return ZKT_SECURE_OK;
}

void zkt_secure_identity_free(zkt_secure_identity_t *identity)
{
    if (!identity) return;
    if (identity->rsa) {
        mbedtls_rsa_free(identity->rsa);
        free(identity->rsa);
    }
    memset(identity, 0, sizeof(*identity));
}

zkt_secure_status_t zkt_secure_dmc_exchange_payload(const zkt_secure_identity_t *identity,
    uint8_t *output, size_t capacity, size_t *written)
{
    if (!identity || !identity->rsa || !identity->pem_length || !output || !written) {
        return ZKT_SECURE_ERR_ARGUMENT;
    }
    uint8_t plain[ZKT_SECURE_PEM_MAX + 9];
    size_t plain_length = 0;
    if (!zkt_secure_dmc_build(DMC_TYPE_PUBLIC_KEY, (const uint8_t *)identity->pem,
            identity->pem_length, plain, sizeof(plain), &plain_length) ||
        !zkt_secure_keystream_apply(plain, plain_length) ||
        mbedtls_base64_encode(output, capacity, written, plain, plain_length) != 0) {
        return ZKT_SECURE_ERR_ENCODING;
    }
    return ZKT_SECURE_OK;
}

/* Replies carry base64 text, sometimes NUL-padded or with whitespace. */
static bool decode_reply(const uint8_t *reply, size_t length, uint8_t *output,
    size_t capacity, size_t *written)
{
    size_t start = 0;
    while (length && reply[length - 1] <= ' ') --length;
    while (start < length && reply[start] <= ' ') ++start;
    return length > start &&
        mbedtls_base64_decode(output, capacity, written, reply + start, length - start) == 0 &&
        *written > 0;
}

static const uint8_t *find_text(const uint8_t *from, const uint8_t *end, const char *text)
{
    size_t length = strlen(text);
    for (const uint8_t *p = from; (size_t)(end - p) >= length; ++p) {
        if (!memcmp(p, text, length)) return p;
    }
    return NULL;
}

static bool der_length(const uint8_t **p, const uint8_t *end, size_t *length)
{
    if (*p >= end) return false;
    uint8_t first = *(*p)++;
    if (!(first & 0x80u)) {
        *length = first;
        return true;
    }
    unsigned count = first & 0x7Fu;
    if (!count || count > 3 || (size_t)(end - *p) < count) return false;
    size_t value = 0;
    while (count--) value = value << 8 | *(*p)++;
    *length = value;
    return true;
}

static bool der_element(const uint8_t **p, const uint8_t *end, uint8_t tag, size_t *length)
{
    return *p < end && *(*p)++ == tag && der_length(p, end, length);
}

static bool der_integer(const uint8_t **p, const uint8_t *end, mbedtls_mpi *value)
{
    size_t length = 0;
    if (!der_element(p, end, MBEDTLS_ASN1_INTEGER, &length) || !length ||
        length > (size_t)(end - *p)) return false;
    bool ok = mbedtls_mpi_read_binary(value, *p, length) == 0;
    *p += length;
    return ok;
}

/* Like the vendor SDK: keep the base64 characters between the armour lines
 * and read SEQUENCE { n, e }, tolerating a declared length past the data.
 * A SubjectPublicKeyInfo wrapper (BEGIN PUBLIC KEY) is unwrapped first. */
static bool parse_peer_key(const uint8_t *body, size_t body_length, uint8_t *scratch,
    size_t capacity, mbedtls_rsa_context *peer)
{
    const uint8_t *end = body + body_length;
    const uint8_t *begin = find_text(body, end, "-----BEGIN");
    if (begin) {
        const uint8_t *armour_end = find_text(begin + 10, end, "-----");
        if (!armour_end) return false;
        body = armour_end + 5;
        const uint8_t *footer = find_text(body, end, "-----END");
        if (footer) end = footer;
    }
    size_t text_length = 0;
    for (const uint8_t *p = body; p < end && text_length < capacity; ++p) {
        uint8_t c = *p;
        if ((c >= 'A' && c <= 'Z') || (c >= 'a' && c <= 'z') || (c >= '0' && c <= '9') ||
            c == '+' || c == '/' || c == '=') scratch[text_length++] = c;
    }
    size_t der_bytes = 0;
    if (!text_length || text_length >= capacity ||
        mbedtls_base64_decode(scratch, capacity, &der_bytes, scratch, text_length) != 0) return false;
    const uint8_t *p = scratch;
    const uint8_t *der_end = scratch + der_bytes;
    size_t length = 0;
    if (!der_element(&p, der_end, MBEDTLS_ASN1_CONSTRUCTED | MBEDTLS_ASN1_SEQUENCE, &length)) return false;
    const uint8_t *sequence_end = length < (size_t)(der_end - p) ? p + length : der_end;
    if (p < sequence_end && *p == (MBEDTLS_ASN1_CONSTRUCTED | MBEDTLS_ASN1_SEQUENCE)) {
        size_t skip = 0;
        if (!der_element(&p, sequence_end, MBEDTLS_ASN1_CONSTRUCTED | MBEDTLS_ASN1_SEQUENCE, &skip) ||
            skip > (size_t)(sequence_end - p)) return false;
        p += skip;
        if (!der_element(&p, sequence_end, MBEDTLS_ASN1_BIT_STRING, &length) ||
            length < 2 || length > (size_t)(sequence_end - p) || *p++ != 0) return false;
        if (!der_element(&p, sequence_end, MBEDTLS_ASN1_CONSTRUCTED | MBEDTLS_ASN1_SEQUENCE, &length)) {
            return false;
        }
        sequence_end = length < (size_t)(sequence_end - p) ? p + length : sequence_end;
    }
    mbedtls_mpi n;
    mbedtls_mpi e;
    mbedtls_mpi_init(&n);
    mbedtls_mpi_init(&e);
    bool ok = der_integer(&p, sequence_end, &n) && der_integer(&p, sequence_end, &e) &&
        mbedtls_rsa_import(peer, &n, NULL, NULL, NULL, &e) == 0 &&
        mbedtls_rsa_complete(peer) == 0 && mbedtls_rsa_check_pubkey(peer) == 0 &&
        mbedtls_rsa_get_len(peer) >= 128 && mbedtls_rsa_get_len(peer) <= 512;
    mbedtls_mpi_free(&n);
    mbedtls_mpi_free(&e);
    return ok;
}

zkt_secure_status_t zkt_secure_key_exchange_payload(const uint8_t *device_reply,
    size_t reply_length, uint32_t client_secret, zkt_secure_rng_t rng, void *rng_context,
    uint8_t *output, size_t capacity, size_t *written)
{
    if (!device_reply || !rng || !output || !written) return ZKT_SECURE_ERR_ARGUMENT;
    struct {
        mbedtls_rsa_context peer;
        uint8_t plain[ZKT_SECURE_MESSAGE_MAX];
        uint8_t scratch[ZKT_SECURE_MESSAGE_MAX];
        uint8_t cipher[512];
    } *work = calloc(1, sizeof(*work));
    if (!work) return ZKT_SECURE_ERR_MEMORY;
    mbedtls_rsa_init(&work->peer);
    zkt_secure_status_t status = ZKT_SECURE_ERR_ENCODING;
    size_t plain_length = 0;
    size_t body_length = 0;
    const uint8_t *body = NULL;
    uint8_t type = 0;
    if (decode_reply(device_reply, reply_length, work->plain, sizeof(work->plain), &plain_length) &&
        zkt_secure_keystream_apply(work->plain, plain_length) &&
        zkt_secure_dmc_parse(work->plain, plain_length, &type, &body, &body_length)) {
        status = ZKT_SECURE_ERR_PEER_KEY;
        if (parse_peer_key(body, body_length, work->scratch, sizeof(work->scratch), &work->peer)) {
            uint8_t secret[4];
            uint8_t message[13];
            size_t message_length = 0;
            put_le32(secret, client_secret);
            status = ZKT_SECURE_ERR_RSA;
            if (zkt_secure_dmc_build(DMC_TYPE_SECRET, secret, sizeof(secret), message,
                    sizeof(message), &message_length) &&
                mbedtls_rsa_pkcs1_encrypt(&work->peer, rng, rng_context, message_length,
                    message, work->cipher) == 0) {
                status = mbedtls_base64_encode(output, capacity, written, work->cipher,
                             mbedtls_rsa_get_len(&work->peer)) == 0
                    ? ZKT_SECURE_OK
                    : ZKT_SECURE_ERR_ENCODING;
            }
        }
    }
    mbedtls_rsa_free(&work->peer);
    free(work);
    return status;
}

zkt_secure_status_t zkt_secure_server_secret(const zkt_secure_identity_t *identity,
    const uint8_t *device_reply, size_t reply_length, zkt_secure_rng_t rng,
    void *rng_context, uint32_t *server_secret)
{
    if (!identity || !identity->rsa || !device_reply || !rng || !server_secret) {
        return ZKT_SECURE_ERR_ARGUMENT;
    }
    struct {
        uint8_t cipher[ZKT_SECURE_MESSAGE_MAX];
        uint8_t plain[512];
    } *work = calloc(1, sizeof(*work));
    if (!work) return ZKT_SECURE_ERR_MEMORY;
    mbedtls_rsa_context *rsa = identity->rsa;
    size_t cipher_length = 0;
    size_t plain_length = 0;
    size_t body_length = 0;
    const uint8_t *body = NULL;
    uint8_t type = 0;
    zkt_secure_status_t status = ZKT_SECURE_ERR_ENCODING;
    if (decode_reply(device_reply, reply_length, work->cipher, sizeof(work->cipher), &cipher_length) &&
        cipher_length == mbedtls_rsa_get_len(rsa)) {
        status = ZKT_SECURE_ERR_RSA;
        if (mbedtls_rsa_pkcs1_decrypt(rsa, rng, rng_context, &plain_length, work->cipher,
                work->plain, sizeof(work->plain)) == 0) {
            status = ZKT_SECURE_ERR_ENCODING;
            if (zkt_secure_dmc_parse(work->plain, plain_length, &type, &body, &body_length) &&
                body_length >= 4) {
                *server_secret = get_le32(body);
                status = ZKT_SECURE_OK;
            }
        }
    }
    free(work);
    return status;
}

static zkt_secure_status_t aes_cbc(const uint8_t key[ZKT_SECURE_KEY_BYTES], int mode,
    uint8_t *data, size_t length)
{
    mbedtls_aes_context aes;
    unsigned char iv[16] = {0};
    mbedtls_aes_init(&aes);
    int result = mode == MBEDTLS_AES_ENCRYPT ? mbedtls_aes_setkey_enc(&aes, key, 256)
                                             : mbedtls_aes_setkey_dec(&aes, key, 256);
    if (result == 0) result = mbedtls_aes_crypt_cbc(&aes, mode, length, iv, data, data);
    mbedtls_aes_free(&aes);
    return result == 0 ? ZKT_SECURE_OK : ZKT_SECURE_ERR_AES;
}

size_t zkt_secure_sealed_length(size_t zk_length)
{
    return (zk_length + ZKT_SECURE_INNER_OVERHEAD + 15u) / 16u * 16u;
}

zkt_secure_status_t zkt_secure_seal(const uint8_t key[ZKT_SECURE_KEY_BYTES],
    const uint8_t *zk, size_t zk_length, uint8_t *frame, size_t capacity,
    size_t *frame_length)
{
    if (!key || !zk || !frame || !frame_length || zk_length < 8 || zk_length > 0x7FFFFFFFu) {
        return ZKT_SECURE_ERR_ARGUMENT;
    }
    size_t sealed = zkt_secure_sealed_length(zk_length);
    if (capacity < ZKT_SECURE_TCP_HEADER_BYTES + sealed) return ZKT_SECURE_ERR_ARGUMENT;
    uint8_t *inner = frame + ZKT_SECURE_TCP_HEADER_BYTES;
    memmove(inner + 6, zk, zk_length);
    inner[0] = 0xAB;
    inner[1] = 0xBB;
    put_le32(inner + 2, (uint32_t)zk_length);
    put_le32(inner + 6 + zk_length, zkt_secure_crc32(inner + 6, zk_length));
    memset(inner + 6 + zk_length + 4, 0, sealed - zk_length - ZKT_SECURE_INNER_OVERHEAD);
    zkt_secure_status_t status = aes_cbc(key, MBEDTLS_AES_ENCRYPT, inner, sealed);
    if (status != ZKT_SECURE_OK) return status;
    put_le16(frame, ZKT_SECURE_TCP_MARKER_1);
    put_le16(frame + 2, ZKT_SECURE_TCP_MARKER_2);
    put_le32(frame + 4, (uint32_t)sealed);
    *frame_length = ZKT_SECURE_TCP_HEADER_BYTES + sealed;
    return ZKT_SECURE_OK;
}

zkt_secure_status_t zkt_secure_open(const uint8_t key[ZKT_SECURE_KEY_BYTES],
    uint8_t *ciphertext, size_t length, size_t *zk_offset, size_t *zk_length)
{
    if (!key || !ciphertext || !zk_offset || !zk_length) return ZKT_SECURE_ERR_ARGUMENT;
    if (!length || length % 16u) return ZKT_SECURE_ERR_FRAME;
    zkt_secure_status_t status = aes_cbc(key, MBEDTLS_AES_DECRYPT, ciphertext, length);
    if (status != ZKT_SECURE_OK) return status;
    if (ciphertext[1] != 0xBB || (ciphertext[0] != 0xAA && ciphertext[0] != 0xAB)) {
        return ZKT_SECURE_ERR_FRAME;
    }
    uint32_t inner = get_le32(ciphertext + 2);
    if (inner < 8 || inner > length - ZKT_SECURE_INNER_OVERHEAD) return ZKT_SECURE_ERR_FRAME;
    /* The vendor SDK accepts a zero CRC from the device. */
    uint32_t crc = get_le32(ciphertext + 6 + inner);
    if (crc && crc != zkt_secure_crc32(ciphertext + 6, inner)) return ZKT_SECURE_ERR_FRAME;
    *zk_offset = 6;
    *zk_length = inner;
    return ZKT_SECURE_OK;
}
